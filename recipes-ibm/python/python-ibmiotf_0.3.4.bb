inherit setuptools
require python-ibmiotf.inc
