inherit setuptools3
require python-ibmiotf.inc
