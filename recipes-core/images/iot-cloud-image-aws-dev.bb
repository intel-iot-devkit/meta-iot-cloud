SUMMARY = "IoT Cloud Amazon Web Services development image"

require iot-cloud-image-aws.bb

IMAGE_FEATURES += "dev-pkgs debug-tweaks ssh-server-dropbear"