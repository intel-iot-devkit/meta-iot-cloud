inherit setuptools3
require python-oisp.inc