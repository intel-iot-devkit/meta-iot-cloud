inherit pypi setuptools
require python-oisp.inc
