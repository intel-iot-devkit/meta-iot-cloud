inherit setuptools
require python-oisp.inc