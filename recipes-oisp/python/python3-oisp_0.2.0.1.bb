inherit pypi setuptools3
require python-oisp.inc
