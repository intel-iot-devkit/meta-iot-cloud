FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://Fix-aarch64-static-linking-into-shared-libraries.patch"

