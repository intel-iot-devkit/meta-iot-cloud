include node-red.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d6f37569f5013072e9490d2194d10ae6"

SRC_URI[md5sum] = "7cb9d56445dee1d8f26699a1bd098e24"
SRC_URI[sha256sum] = "7fdae4b2d1ca2c309aeff7a9148a1dfe95b62223f54be78ac20028b6e42c10df"
