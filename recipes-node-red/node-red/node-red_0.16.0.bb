include node-red.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d6f37569f5013072e9490d2194d10ae6"

SRC_URI[md5sum] = "8c24b22f83e50bb84e5f0260b5e2b934"
SRC_URI[sha256sum] = "f22878f47207a6a4b54692fec69a48637417f83c645c2d97c59d677aa50bd9c9"

PR = "r0"
