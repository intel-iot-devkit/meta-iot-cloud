include node-red.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d6f37569f5013072e9490d2194d10ae6"

SRC_URI[md5sum] = "cdf3813498d70914b46c191f319831b7"
SRC_URI[sha256sum] = "3ae3baac873803a09dbb01a0e6a7fde2b19c3d59fa5f69ff3ad44a70f33e3dec"

PR = "r0"
