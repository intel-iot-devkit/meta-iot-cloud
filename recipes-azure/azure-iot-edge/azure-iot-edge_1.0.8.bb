DESCRIPTION = "Azure IoT Edge"
AUTHOR = "Microsoft Corporation"
HOMEPAGE = "https://github.com/Azure/iot-edge"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://License.txt;md5=faecdf5ffdbb00b2ad988ee32fae9a2d"

SRC_URI = "git://github.com/Azure/iot-edge.git"
SRCREV = "ac819371fd8cd43bac1e403dbc3a7b58a2cc5d6e"

PR = "r0"

require ${PN}.inc
