inherit setuptools
require python-azure-mgmt-dns.inc
require python-azure-class.inc
