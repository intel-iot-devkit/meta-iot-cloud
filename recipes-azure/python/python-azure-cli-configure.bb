inherit setuptools
require python-azure-cli-configure.inc
require azure-cli-common.inc
