inherit setuptools3
require python-azure-mgmt-servermanager.inc
require python-azure-class.inc
