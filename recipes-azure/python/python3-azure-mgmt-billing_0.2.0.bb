inherit setuptools3
require python-azure-mgmt-billing.inc
