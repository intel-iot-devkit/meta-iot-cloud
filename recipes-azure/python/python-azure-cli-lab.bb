inherit setuptools
require python-azure-cli-lab.inc
require azure-cli-command-modules.inc
