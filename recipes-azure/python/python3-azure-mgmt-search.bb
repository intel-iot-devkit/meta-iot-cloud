inherit setuptools3
require python-azure-mgmt-search.inc
require python-azure-class.inc
