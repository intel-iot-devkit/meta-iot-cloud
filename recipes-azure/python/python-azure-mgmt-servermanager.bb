inherit setuptools
require python-azure-mgmt-servermanager.inc
require python-azure-class.inc
