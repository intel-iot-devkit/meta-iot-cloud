inherit setuptools
require python-azure-cli-interactive.inc
require azure-cli-common.inc
