inherit pypi setuptools
require python-azure-cli-reservations.inc