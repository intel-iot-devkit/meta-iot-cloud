inherit setuptools
require python-azure-mgmt-rdbms.inc
require azure-mgmt-common.inc
