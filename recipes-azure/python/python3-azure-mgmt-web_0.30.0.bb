inherit setuptools3
require python-azure-mgmt-web.inc
require python-azure-class.inc
