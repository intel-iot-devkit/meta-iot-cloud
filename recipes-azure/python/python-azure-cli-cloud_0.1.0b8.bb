inherit setuptools
require python-azure-cli-cloud.inc
require python-azure-cli-common.inc
