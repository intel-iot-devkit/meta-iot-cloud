inherit setuptools
require python-azure-cli-monitor.inc
require azure-cli-command-modules.inc
