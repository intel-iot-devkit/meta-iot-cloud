inherit setuptools3
require python-azure-mgmt-sql.inc
require azure-mgmt-common.inc
