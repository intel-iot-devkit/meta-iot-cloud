inherit setuptools
require python-azure-mgmt-containerinstance.inc
