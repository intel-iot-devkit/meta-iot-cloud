inherit setuptools
require python-azure-cli-feedback.inc
require azure-cli-command-modules.inc
