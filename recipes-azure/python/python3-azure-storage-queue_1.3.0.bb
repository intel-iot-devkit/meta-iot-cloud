inherit pypi setuptools3
require python-azure-storage-queue.inc