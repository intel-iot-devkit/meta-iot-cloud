inherit setuptools3
require python-azure-mgmt-keyvault.inc
require azure-mgmt-common.inc
