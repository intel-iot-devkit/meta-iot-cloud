inherit setuptools3
require python-azure-mgmt-web.inc
require azure-mgmt-common.inc
