inherit setuptools
require python-azure-mgmt-cdn.inc
