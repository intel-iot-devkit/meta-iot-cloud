inherit setuptools
require python-azure-mgmt-marketplaceordering.inc