inherit setuptools
require python-azure-mgmt-keyvault.inc
require azure-mgmt-common.inc
