inherit pypi setuptools
require python-azure-cli-nspkg.inc