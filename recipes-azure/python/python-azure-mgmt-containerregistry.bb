inherit setuptools
require python-azure-mgmt-containerregistry.inc
require azure-mgmt-common.inc
