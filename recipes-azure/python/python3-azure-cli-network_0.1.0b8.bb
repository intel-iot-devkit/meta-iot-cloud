inherit setuptools3
require python-azure-cli-network.inc
require python-azure-cli-common.inc
