inherit setuptools3
require python-azure-mgmt-redis.inc
require python-azure-class.inc
