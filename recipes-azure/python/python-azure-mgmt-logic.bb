inherit setuptools
require python-azure-mgmt-logic.inc
require python-azure-class.inc
