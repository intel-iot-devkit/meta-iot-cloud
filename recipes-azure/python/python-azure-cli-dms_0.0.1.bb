inherit pypi setuptools
require python-azure-cli-dms.inc