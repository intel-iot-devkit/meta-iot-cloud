inherit pypi setuptools
require python-applicationinsights.inc

RDEPENDS_${PN} += "\
	${PYTHON_PN}-lang \
"