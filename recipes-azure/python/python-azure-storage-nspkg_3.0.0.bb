inherit pypi setuptools
require python-azure-storage-nspkg.inc
