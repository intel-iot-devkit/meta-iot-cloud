inherit setuptools3
require python-azure-cli-batch.inc
require azure-cli-command-modules.inc
