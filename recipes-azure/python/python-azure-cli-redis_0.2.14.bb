inherit pypi setuptools
require python-azure-cli-redis.inc