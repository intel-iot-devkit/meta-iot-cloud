inherit setuptools3
require python-azure-nspkg.inc