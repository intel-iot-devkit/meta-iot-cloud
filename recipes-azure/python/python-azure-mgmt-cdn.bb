inherit setuptools
require python-azure-mgmt-cdn.inc
require azure-mgmt-common.inc
