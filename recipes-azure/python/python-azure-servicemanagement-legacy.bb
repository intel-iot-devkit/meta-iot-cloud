inherit setuptools
require python-azure-servicemanagement-legacy.inc
require azure-sdk-common.inc
