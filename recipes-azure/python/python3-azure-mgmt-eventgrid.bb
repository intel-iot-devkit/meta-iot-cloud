inherit setuptools3
require python-azure-mgmt-eventgrid.inc
require azure-mgmt-common.inc
