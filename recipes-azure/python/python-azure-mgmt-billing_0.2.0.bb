inherit setuptools
require python-azure-mgmt-billing.inc
