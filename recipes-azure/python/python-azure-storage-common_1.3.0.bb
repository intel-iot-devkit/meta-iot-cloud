inherit pypi setuptools
require python-azure-storage-common.inc
