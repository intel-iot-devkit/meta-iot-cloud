inherit setuptools
require python-azure-cli-common.inc
require python-azure-cli.inc
