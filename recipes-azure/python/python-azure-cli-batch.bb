inherit setuptools
require python-azure-cli-batch.inc
require azure-cli-common.inc
