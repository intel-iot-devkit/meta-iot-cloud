inherit setuptools
require python-azure-cli-dla.inc
require azure-cli-command-modules.inc
