inherit setuptools
require python-azure-cli-storage.inc
require python-azure-cli-common.inc
