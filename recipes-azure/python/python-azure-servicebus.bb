inherit setuptools
require python-azure-servicebus.inc
require azure-sdk-common.inc
