inherit setuptools3
require python-azure-cli.inc
require azure-cli-common.inc
