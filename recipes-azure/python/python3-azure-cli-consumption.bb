inherit setuptools3
require python-azure-cli-consumption.inc
require azure-cli-command-modules.inc
