inherit setuptools
require python-azure-mgmt-containerservice.inc
require azure-mgmt-common.inc
