inherit setuptools
require python-azure-iothub-provisioningserviceclient.inc
