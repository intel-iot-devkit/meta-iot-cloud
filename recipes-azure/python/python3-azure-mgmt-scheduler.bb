inherit setuptools3
require python-azure-mgmt-scheduler.inc
require python-azure-class.inc
