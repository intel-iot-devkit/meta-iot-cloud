inherit setuptools3
require python-azure-cli-container.inc
require azure-cli-command-modules.inc
