inherit pypi setuptools
require python-azure-cli-rdbms.inc