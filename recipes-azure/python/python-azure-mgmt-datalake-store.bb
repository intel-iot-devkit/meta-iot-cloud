inherit setuptools
require python-azure-mgmt-datalake-store.inc
require python-azure-class.inc
