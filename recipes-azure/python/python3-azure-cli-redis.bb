inherit setuptools3
require python-azure-cli-redis.inc
require python-azure-cli-common.inc
