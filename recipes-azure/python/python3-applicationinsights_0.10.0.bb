inherit setuptools3
require python-applicationinsights.inc
