inherit setuptools
require python-azure-mgmt-cdn.inc
require python-azure-class.inc
