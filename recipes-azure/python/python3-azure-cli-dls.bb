inherit setuptools3
require python-azure-cli-dls.inc
require azure-cli-command-modules.inc
