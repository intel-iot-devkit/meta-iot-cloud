inherit setuptools
require python-azure-mgmt-media.inc
require azure-mgmt-common.inc
