inherit setuptools3
require python-azure-mgmt-cognitiveservices.inc
require python-azure-class.inc
