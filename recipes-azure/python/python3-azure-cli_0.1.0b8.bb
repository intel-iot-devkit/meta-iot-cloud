inherit setuptools3
require python-azure-cli-common.inc
require python-azure-cli.inc
