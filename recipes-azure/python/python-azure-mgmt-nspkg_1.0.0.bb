inherit setuptools
require python-azure-mgmt-nspkg.inc
require python-azure-class.inc
