inherit pypi setuptools
require python-azure-cli-cloud.inc
