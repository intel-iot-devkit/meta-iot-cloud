inherit setuptools3
require python-vsts-cd-manager.inc
