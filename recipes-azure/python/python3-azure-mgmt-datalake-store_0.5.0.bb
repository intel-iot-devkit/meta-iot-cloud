inherit setuptools3
require python-azure-mgmt-datalake-store.inc