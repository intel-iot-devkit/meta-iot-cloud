inherit setuptools
require python-azure-mgmt-batch.inc
require azure-mgmt-common.inc
