inherit setuptools3
require python-azure-mgmt-billing.inc
require azure-mgmt-common.inc
