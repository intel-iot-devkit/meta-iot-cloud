inherit setuptools3
require python-azure-monitor.inc
require python-azure-class.inc
