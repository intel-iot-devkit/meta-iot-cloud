inherit setuptools3
require python-azure-mgmt-dns.inc