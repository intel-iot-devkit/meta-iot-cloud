inherit pypi setuptools
require python-azure-cli-cosmosdb.inc