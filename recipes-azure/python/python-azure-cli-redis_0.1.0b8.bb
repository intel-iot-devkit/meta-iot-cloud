inherit setuptools
require python-azure-cli-redis.inc
require python-azure-cli-common.inc
