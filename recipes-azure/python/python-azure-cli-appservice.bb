inherit setuptools
require python-azure-cli-appservice.inc
require python-azure-cli-common.inc
