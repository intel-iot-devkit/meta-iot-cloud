inherit setuptools3
require python-azure-cli-extension.inc
require azure-cli-command-modules.inc
