inherit setuptools
require python-azure-cli-vm.inc
require azure-cli-common.inc
