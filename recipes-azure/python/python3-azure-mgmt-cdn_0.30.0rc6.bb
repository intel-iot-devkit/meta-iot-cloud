inherit setuptools3
require python-azure-mgmt-cdn.inc
require python-azure-class.inc
