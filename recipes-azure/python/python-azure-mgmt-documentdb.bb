inherit setuptools
require python-azure-mgmt-documentdb.inc
require azure-mgmt-common.inc
