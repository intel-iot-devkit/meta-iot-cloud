inherit setuptools
require python-azure-mgmt-compute.inc
require python-azure-class.inc
