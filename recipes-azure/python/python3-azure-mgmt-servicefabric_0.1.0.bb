inherit setuptools3
require python-azure-mgmt-servicefabric.inc