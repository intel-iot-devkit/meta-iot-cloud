inherit setuptools
require python-azure-cli-servicefabric.inc
require azure-cli-command-modules.inc
