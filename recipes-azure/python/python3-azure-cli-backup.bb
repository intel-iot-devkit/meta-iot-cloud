inherit setuptools3
require python-azure-cli-backup.inc
require azure-cli-command-modules.inc
