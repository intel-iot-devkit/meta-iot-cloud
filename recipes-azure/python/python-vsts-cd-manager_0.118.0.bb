inherit setuptools
require python-vsts-cd-manager.inc
