inherit setuptools
require python-azure-cli-role.inc
require python-azure-cli-common.inc
