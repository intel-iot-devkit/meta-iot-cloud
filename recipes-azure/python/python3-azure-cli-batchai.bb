inherit setuptools3
require python-azure-cli-batchai.inc
require azure-cli-command-modules.inc
