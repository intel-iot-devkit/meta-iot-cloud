inherit setuptools3
require python-azure-keyvault.inc