inherit setuptools3
require python-azure-mgmt-powerbiembedded.inc
require azure-mgmt-common.inc
