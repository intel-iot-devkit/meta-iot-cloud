inherit setuptools3
require python-azure-mgmt-documentdb.inc
require azure-mgmt-common.inc
