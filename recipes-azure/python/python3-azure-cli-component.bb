inherit setuptools3
require python-azure-cli-component.inc
require azure-cli-command-modules.inc
