inherit setuptools3
require python-azure-graphrbac.inc
require azure-sdk-common.inc
