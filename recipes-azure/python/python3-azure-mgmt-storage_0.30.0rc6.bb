inherit setuptools3
require python-azure-mgmt-storage.inc
require python-azure-class.inc
