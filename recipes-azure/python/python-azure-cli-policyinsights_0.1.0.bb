inherit pypi setuptools
require python-azure-cli-policyinsights.inc