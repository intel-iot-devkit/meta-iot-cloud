inherit pypi setuptools
require python-azure-cli-feedback.inc