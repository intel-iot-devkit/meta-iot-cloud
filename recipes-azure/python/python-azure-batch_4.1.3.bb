inherit setuptools
require python-azure-batch.inc
