inherit setuptools3
require python-azure-cli-servicefabric.inc
require azure-cli-command-modules.inc
