inherit setuptools3
require python-azure-cli-vm.inc
require azure-cli-common.inc
