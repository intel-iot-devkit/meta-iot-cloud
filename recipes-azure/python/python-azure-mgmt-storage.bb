inherit setuptools
require python-azure-mgmt-storage.inc
require python-azure-class.inc
