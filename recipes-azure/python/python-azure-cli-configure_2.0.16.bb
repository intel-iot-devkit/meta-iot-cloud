inherit pypi setuptools
require python-azure-cli-configure.inc