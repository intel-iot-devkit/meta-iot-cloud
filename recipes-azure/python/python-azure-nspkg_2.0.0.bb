inherit setuptools
require python-azure-nspkg.inc