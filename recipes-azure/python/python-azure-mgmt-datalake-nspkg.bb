inherit setuptools
require python-azure-mgmt-datalake-nspkg.inc
require python-azure-class.inc
