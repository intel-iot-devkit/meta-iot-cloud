inherit setuptools3
require python-azure-servicebus.inc
require azure-sdk-common.inc
