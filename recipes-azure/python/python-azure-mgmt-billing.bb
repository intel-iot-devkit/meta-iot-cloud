inherit setuptools
require python-azure-mgmt-billing.inc
require azure-mgmt-common.inc
