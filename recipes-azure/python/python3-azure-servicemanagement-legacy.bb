inherit setuptools3
require python-azure-servicemanagement-legacy.inc
require azure-sdk-common.inc
