inherit setuptools3
require python-azure-mgmt-media.inc
require python-azure-class.inc
