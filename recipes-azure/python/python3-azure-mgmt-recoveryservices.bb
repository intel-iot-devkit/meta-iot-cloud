inherit setuptools3
require python-azure-mgmt-recoveryservices.inc
require azure-mgmt-common.inc
