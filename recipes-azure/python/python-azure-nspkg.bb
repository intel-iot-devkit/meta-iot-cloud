inherit setuptools
require python-azure-nspkg.inc
require azure-sdk.inc
