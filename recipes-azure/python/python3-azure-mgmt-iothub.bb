inherit setuptools3
require python-azure-mgmt-iothub.inc
require python-azure-class.inc
