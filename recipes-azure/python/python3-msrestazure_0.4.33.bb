inherit pypi setuptools3
require python-msrestazure.inc
