inherit setuptools
require python-azure-mgmt-recoveryservicesbackup.inc
