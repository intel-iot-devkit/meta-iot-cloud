inherit pypi setuptools
require python-azure-cli-servicebus.inc