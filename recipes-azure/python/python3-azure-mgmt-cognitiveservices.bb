inherit setuptools3
require python-azure-mgmt-cognitiveservices.inc
require azure-mgmt-common.inc
