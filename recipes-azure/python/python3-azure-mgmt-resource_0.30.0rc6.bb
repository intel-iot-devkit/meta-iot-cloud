inherit setuptools3
require python-azure-mgmt-resource.inc
require python-azure-class.inc
