inherit setuptools
require python-azure-cli-documentdb.inc
require azure-cli-common.inc
