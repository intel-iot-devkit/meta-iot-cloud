inherit setuptools
require python-azure-cli-rdbms.inc
require azure-cli-common.inc
