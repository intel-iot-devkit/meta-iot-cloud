inherit setuptools
require python-azure-mgmt-iothub.inc
require python-azure-class.inc
