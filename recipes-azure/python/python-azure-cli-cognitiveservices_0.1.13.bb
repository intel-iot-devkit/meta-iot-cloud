inherit pypi setuptools
require python-azure-cli-cognitiveservices.inc
