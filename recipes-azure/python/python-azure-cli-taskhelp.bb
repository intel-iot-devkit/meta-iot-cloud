inherit setuptools
require python-azure-cli-taskhelp.inc
require azure-cli-common.inc
