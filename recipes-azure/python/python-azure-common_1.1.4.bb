inherit setuptools
require python-azure-common.inc
require python-azure-class.inc
