inherit setuptools3
require python-azure-servicebus.inc
require python-azure-class.inc
