inherit setuptools3
require python-azure-servicefabric.inc
require azure-sdk-common.inc
