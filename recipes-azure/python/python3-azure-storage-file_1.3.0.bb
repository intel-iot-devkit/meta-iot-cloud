inherit pypi setuptools3
require python-azure-storage-file.inc