inherit setuptools3
require python-msrestazure.inc
