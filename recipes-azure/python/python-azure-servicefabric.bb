inherit setuptools
require python-azure-servicefabric.inc
require azure-sdk-common.inc
