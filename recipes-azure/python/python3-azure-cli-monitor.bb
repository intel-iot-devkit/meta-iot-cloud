inherit setuptools3
require python-azure-cli-monitor.inc
require azure-cli-common.inc
