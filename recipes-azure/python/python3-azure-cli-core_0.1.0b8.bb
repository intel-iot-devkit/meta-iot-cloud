inherit setuptools3
require python-azure-cli-core.inc
require python-azure-cli-common.inc
