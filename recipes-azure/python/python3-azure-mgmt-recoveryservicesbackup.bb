inherit setuptools3
require python-azure-mgmt-recoveryservicesbackup.inc
require azure-mgmt-common.inc
