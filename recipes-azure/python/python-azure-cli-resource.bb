inherit setuptools
require python-azure-cli-resource.inc
require python-azure-cli-common.inc
