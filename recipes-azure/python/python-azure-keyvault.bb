inherit setuptools
require python-azure-keyvault.inc
require python-azure-class.inc
