inherit setuptools
require python-azure-cli-cognitiveservices.inc
require azure-cli-command-modules.inc
