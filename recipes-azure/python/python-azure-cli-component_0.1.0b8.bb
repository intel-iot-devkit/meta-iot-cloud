inherit setuptools
require python-azure-cli-component.inc
require python-azure-cli-common.inc
