inherit setuptools
require python-azure-mgmt-keyvault.inc
require python-azure-class.inc
