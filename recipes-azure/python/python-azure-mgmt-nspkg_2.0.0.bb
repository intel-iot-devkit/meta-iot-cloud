inherit setuptools
require python-azure-mgmt-nspkg.inc