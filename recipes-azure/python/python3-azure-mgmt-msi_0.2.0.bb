inherit setuptools3
require python-azure-mgmt-msi.inc