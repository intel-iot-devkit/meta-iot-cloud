inherit setuptools3
require python-azure-mgmt-batch.inc
require azure-mgmt-common.inc
