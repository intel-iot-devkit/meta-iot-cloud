inherit setuptools
require python-azure-mgmt-servicefabric.inc
require azure-mgmt-common.inc
