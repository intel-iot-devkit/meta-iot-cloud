inherit pypi setuptools3
require python-azure-cli-dls.inc