inherit setuptools
require python-azure-cli-profile.inc
require azure-cli-common.inc
