inherit setuptools3
require python-azure-mgmt-authorization.inc
require azure-mgmt-common.inc
