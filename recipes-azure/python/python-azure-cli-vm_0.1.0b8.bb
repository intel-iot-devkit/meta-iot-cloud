inherit setuptools
require python-azure-cli-vm.inc
require python-azure-cli-common.inc
