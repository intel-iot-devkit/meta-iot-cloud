inherit setuptools3
require python-azure-mgmt-trafficmanager.inc
require python-azure-class.inc
