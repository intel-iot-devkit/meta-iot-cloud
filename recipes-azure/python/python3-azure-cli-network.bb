inherit setuptools3
require python-azure-cli-network.inc
require azure-cli-command-modules.inc
