inherit setuptools3
require python-azure-cli-cosmosdb.inc
require azure-cli-command-modules.inc
