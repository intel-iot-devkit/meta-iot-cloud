inherit setuptools
require python-azure-mgmt-batch.inc
require python-azure-class.inc
