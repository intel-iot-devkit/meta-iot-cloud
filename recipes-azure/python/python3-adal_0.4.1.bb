inherit setuptools3
require python-adal.inc
