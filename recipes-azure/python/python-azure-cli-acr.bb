inherit setuptools
require python-azure-cli-acr.inc
require python-azure-cli-common.inc
