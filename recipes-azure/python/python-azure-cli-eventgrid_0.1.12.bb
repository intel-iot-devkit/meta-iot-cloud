inherit pypi setuptools
require python-azure-cli-eventgrid.inc