inherit setuptools3
require python-azure-cli-appservice.inc
require python-azure-cli-common.inc
