inherit pypi setuptools
require python-azure-cli-ams.inc
