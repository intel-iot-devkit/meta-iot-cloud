inherit setuptools3
require python-azure-cli-cloud.inc
require python-azure-cli-common.inc
