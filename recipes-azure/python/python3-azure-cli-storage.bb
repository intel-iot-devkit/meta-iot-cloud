inherit setuptools3
require python-azure-cli-storage.inc
require azure-cli-common.inc
