inherit setuptools3
require python-azure-mgmt-servicebus.inc
require python-azure-class.inc
