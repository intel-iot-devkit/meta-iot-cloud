inherit setuptools3
require python-azure-mgmt-datalake-analytics.inc