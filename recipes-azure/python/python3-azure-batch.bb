inherit setuptools3
require python-azure-batch.inc
require python-azure-class.inc
