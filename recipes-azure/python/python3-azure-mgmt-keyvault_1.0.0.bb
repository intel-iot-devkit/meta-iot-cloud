inherit setuptools3
require python-azure-mgmt-keyvault.inc
