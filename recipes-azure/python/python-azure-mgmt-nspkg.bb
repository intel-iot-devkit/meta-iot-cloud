inherit setuptools
require python-azure-mgmt-nspkg.inc
require azure-sdk-common.inc
