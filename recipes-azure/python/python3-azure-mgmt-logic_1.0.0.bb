inherit setuptools3
require python-azure-mgmt-logic.inc
require python-azure-class.inc
