inherit setuptools3
require python-azure-mgmt-notificationhubs.inc
require python-azure-class.inc
