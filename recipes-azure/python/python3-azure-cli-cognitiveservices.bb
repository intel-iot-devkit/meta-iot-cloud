inherit setuptools3
require python-azure-cli-cognitiveservices.inc
require azure-cli-command-modules.inc
