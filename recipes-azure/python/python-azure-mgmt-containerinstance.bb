inherit setuptools
require python-azure-mgmt-containerinstance.inc
require azure-mgmt-common.inc
