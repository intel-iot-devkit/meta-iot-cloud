inherit setuptools
require python-azure-cli-cosmosdb.inc
require azure-cli-common.inc
