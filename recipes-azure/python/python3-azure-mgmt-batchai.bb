inherit setuptools3
require python-azure-mgmt-batchai.inc
require azure-mgmt-common.inc
