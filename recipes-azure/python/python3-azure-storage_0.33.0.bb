inherit setuptools3
require azure-sdk-common.inc
