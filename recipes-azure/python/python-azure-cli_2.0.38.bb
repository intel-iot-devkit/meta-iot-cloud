inherit pypi setuptools
require python-azure-cli.inc
