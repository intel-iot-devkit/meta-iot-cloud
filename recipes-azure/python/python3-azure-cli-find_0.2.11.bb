inherit pypi setuptools3
require python-azure-cli-find.inc