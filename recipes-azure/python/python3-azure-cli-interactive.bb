inherit setuptools3
require python-azure-cli-interactive.inc
require azure-cli-common.inc
