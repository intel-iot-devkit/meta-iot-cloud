inherit setuptools
require python-azure-mgmt-batchai.inc
require azure-mgmt-common.inc
