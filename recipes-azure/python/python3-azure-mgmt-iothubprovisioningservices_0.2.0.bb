inherit setuptools3
require python-azure-mgmt-iothubprovisioningservices.inc