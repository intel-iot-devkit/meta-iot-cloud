inherit setuptools
require python-azure-cli-cloud.inc
require azure-cli-command-modules.inc
