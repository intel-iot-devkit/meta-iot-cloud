inherit setuptools3
require python-azure-mgmt-consumption.inc
require azure-mgmt-common.inc
