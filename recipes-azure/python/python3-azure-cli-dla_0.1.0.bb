inherit pypi setuptools3
require python-azure-cli-dla.inc