inherit pypi setuptools
require python-azure-cli-billing.inc
