inherit pypi setuptools3
require python-azure-cli-command-modules-nspkg.inc