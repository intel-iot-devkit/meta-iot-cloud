inherit setuptools
require python-azure-mgmt-sql.inc
require azure-mgmt-common.inc
