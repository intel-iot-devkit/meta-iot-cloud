inherit setuptools3
require python-azure-mgmt-cdn.inc
require azure-mgmt-common.inc
