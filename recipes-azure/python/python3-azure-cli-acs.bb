inherit setuptools3
require python-azure-cli-acs.inc
require python-azure-cli-common.inc
