inherit setuptools
require python-azure-cli-nspkg.inc
require azure-cli.inc
