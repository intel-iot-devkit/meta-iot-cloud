inherit setuptools
require python-azure-mgmt-authorization.inc
require azure-mgmt-common.inc
