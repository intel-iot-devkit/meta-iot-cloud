inherit pypi setuptools3
require python-azure-storage-nspkg.inc
