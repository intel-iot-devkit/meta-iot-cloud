inherit setuptools3
require python-azure-mgmt-logic.inc
require azure-mgmt-common.inc
