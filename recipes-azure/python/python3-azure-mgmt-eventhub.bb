inherit setuptools3
require python-azure-mgmt-eventhub.inc
require python-azure-class.inc
