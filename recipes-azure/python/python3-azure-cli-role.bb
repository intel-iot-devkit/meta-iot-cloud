inherit setuptools3
require python-azure-cli-role.inc
require python-azure-cli-common.inc
