inherit setuptools
require python-azure-cli-command-modules-nspkg.inc
require azure-cli.inc
