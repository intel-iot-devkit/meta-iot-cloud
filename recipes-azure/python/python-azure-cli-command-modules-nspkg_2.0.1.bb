inherit pypi setuptools
require python-azure-cli-command-modules-nspkg.inc