inherit pypi setuptools
require python-azure-cli-dls.inc