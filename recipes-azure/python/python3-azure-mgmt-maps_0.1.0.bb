inherit setuptools3
require python-azure-mgmt-maps.inc