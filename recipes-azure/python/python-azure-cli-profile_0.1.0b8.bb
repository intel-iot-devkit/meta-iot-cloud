inherit setuptools
require python-azure-cli-profile.inc
require python-azure-cli-common.inc
