inherit setuptools3
require python-azure-mgmt-rdbms.inc
require azure-mgmt-common.inc
