inherit setuptools3
require python-azure-multiapi-storage.inc
