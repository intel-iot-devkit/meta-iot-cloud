inherit setuptools3
require python-azure-mgmt-devtestlabs.inc