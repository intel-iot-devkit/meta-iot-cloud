inherit setuptools
require python-azure-mgmt-network.inc
require azure-mgmt-common.inc
