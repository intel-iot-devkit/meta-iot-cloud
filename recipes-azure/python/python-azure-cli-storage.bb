inherit setuptools
require python-azure-cli-storage.inc
require azure-cli-common.inc
