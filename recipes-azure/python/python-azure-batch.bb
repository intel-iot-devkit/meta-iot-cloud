inherit setuptools
require python-azure-batch.inc
require azure-sdk-common.inc
