inherit setuptools3
require python-azure-mgmt-iothub.inc