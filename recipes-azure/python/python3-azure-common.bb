inherit setuptools3
require python-azure-common.inc
require azure-sdk-common.inc
