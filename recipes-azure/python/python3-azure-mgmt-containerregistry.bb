inherit setuptools3
require python-azure-mgmt-containerregistry.inc
require python-azure-class.inc
