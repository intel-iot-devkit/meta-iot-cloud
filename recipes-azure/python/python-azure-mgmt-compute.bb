inherit setuptools
require python-azure-mgmt-compute.inc
require azure-mgmt-common.inc
