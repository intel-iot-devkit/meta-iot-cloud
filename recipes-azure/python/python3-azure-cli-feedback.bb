inherit setuptools3
require python-azure-cli-feedback.inc
require python-azure-cli-common.inc
