inherit setuptools
require python-azure-cli-taskhelp.inc
require python-azure-cli-common.inc
