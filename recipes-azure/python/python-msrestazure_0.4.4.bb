inherit setuptools
require python-msrestazure.inc
