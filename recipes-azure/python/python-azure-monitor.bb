inherit setuptools
require python-azure-monitor.inc
require azure-sdk-common.inc
