inherit setuptools
require python-azure.inc
