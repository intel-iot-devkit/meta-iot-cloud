inherit setuptools3
require python-azure-cli-eventgrid.inc
require azure-cli-command-modules.inc
