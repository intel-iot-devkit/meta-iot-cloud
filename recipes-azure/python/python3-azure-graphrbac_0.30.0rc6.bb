inherit setuptools3
require python-azure-graphrbac.inc
require python-azure-class.inc
