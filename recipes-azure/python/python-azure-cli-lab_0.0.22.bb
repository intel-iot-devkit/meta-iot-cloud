inherit pypi setuptools
require python-azure-cli-lab.inc