inherit setuptools
require python-azure-cli-container.inc
require azure-cli-command-modules.inc
