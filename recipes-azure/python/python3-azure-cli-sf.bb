inherit setuptools3
require python-azure-cli-sf.inc
require azure-cli-common.inc
