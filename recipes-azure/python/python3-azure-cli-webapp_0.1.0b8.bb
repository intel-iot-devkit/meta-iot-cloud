inherit setuptools3
require python-azure-cli-webapp.inc
require python-azure-cli-common.inc
