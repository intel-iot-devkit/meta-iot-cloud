inherit pypi setuptools3
require python-azure-cli-interactive.inc