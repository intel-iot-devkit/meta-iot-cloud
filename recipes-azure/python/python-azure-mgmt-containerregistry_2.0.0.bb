inherit setuptools
require python-azure-mgmt-containerregistry.inc
