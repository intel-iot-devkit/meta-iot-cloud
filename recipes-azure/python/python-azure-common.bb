inherit setuptools
require python-azure-common.inc
require azure-sdk-common.inc
