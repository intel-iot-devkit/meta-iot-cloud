inherit pypi setuptools
require python-azure-cli-resource.inc