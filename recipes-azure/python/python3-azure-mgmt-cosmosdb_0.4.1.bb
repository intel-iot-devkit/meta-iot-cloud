inherit setuptools3
require python-azure-mgmt-cosmosdb.inc