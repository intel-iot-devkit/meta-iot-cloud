inherit setuptools
require python-azure-cli-iot.inc
require python-azure-cli-common.inc
