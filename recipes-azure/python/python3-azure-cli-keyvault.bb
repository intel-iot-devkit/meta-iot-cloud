inherit setuptools3
require python-azure-cli-keyvault.inc
require azure-cli-common.inc
