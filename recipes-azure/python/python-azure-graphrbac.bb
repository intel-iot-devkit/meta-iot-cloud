inherit setuptools
require python-azure-graphrbac.inc
require azure-sdk-common.inc
