inherit setuptools
require python-azure-mgmt-batchai.inc
