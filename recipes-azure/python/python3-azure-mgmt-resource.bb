inherit setuptools3
require python-azure-mgmt-resource.inc
require azure-mgmt-common.inc
