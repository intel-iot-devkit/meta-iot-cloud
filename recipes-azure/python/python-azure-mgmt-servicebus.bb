inherit setuptools
require python-azure-mgmt-servicebus.inc
require azure-mgmt-common.inc
