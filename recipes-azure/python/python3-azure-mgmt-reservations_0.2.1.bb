inherit setuptools3
require python-azure-mgmt-reservations.inc