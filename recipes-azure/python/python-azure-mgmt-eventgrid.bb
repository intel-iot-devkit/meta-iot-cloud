inherit setuptools
require python-azure-mgmt-eventgrid.inc
require azure-mgmt-common.inc
