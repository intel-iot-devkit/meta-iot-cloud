inherit pypi setuptools
require python-azure-cli-advisor.inc
