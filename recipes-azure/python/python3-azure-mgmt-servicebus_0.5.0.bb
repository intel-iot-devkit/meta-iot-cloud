inherit setuptools3
require python-azure-mgmt-servicebus.inc