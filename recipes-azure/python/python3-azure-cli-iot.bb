inherit setuptools3
require python-azure-cli-iot.inc
require azure-cli-command-modules.inc
