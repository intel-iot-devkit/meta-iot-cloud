inherit setuptools3
require python-azure-cli-context.inc
require python-azure-cli-common.inc
