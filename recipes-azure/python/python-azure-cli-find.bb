inherit setuptools
require python-azure-cli-find.inc
require azure-cli-command-modules.inc
