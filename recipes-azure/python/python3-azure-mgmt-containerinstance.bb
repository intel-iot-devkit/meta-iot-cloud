inherit setuptools3
require python-azure-mgmt-containerinstance.inc
require azure-mgmt-common.inc
