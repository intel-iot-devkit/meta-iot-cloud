inherit setuptools
require python-azure-cli-acs.inc
require azure-cli-common.inc
