inherit setuptools3
require python-azure-cli-configure.inc
require python-azure-cli-common.inc
