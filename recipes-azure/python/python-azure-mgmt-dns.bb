inherit setuptools
require python-azure-mgmt-dns.inc
require azure-mgmt-common.inc
