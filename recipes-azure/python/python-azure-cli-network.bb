inherit setuptools
require python-azure-cli-network.inc
require python-azure-cli-common.inc
