inherit pypi setuptools
require python-azure-cli-backup.inc
