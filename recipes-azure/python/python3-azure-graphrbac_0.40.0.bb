inherit setuptools3
require python-azure-graphrbac.inc
