inherit setuptools3
require python-azure-cli-lab.inc
require azure-cli-common.inc
