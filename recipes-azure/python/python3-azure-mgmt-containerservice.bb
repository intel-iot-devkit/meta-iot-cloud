inherit setuptools3
require python-azure-mgmt-containerservice.inc
require azure-mgmt-common.inc
