inherit setuptools
require python-azure-mgmt-datalake-nspkg.inc
