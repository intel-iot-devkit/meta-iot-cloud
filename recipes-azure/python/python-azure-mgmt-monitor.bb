inherit setuptools
require python-azure-mgmt-monitor.inc
require azure-mgmt-common.inc
