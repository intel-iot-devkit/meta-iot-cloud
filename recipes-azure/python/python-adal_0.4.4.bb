inherit setuptools
require python-adal.inc
