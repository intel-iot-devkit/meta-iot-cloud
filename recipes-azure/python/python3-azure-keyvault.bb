inherit setuptools3
require python-azure-keyvault.inc
require azure-sdk-common.inc
