inherit setuptools3
require python-azure-mgmt-monitor.inc