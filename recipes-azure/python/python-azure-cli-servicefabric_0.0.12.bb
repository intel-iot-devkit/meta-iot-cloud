inherit pypi setuptools
require python-azure-cli-servicefabric.inc