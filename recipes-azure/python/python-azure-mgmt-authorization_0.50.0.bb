inherit setuptools
require python-azure-mgmt-authorization.inc