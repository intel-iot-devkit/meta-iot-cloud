inherit setuptools3
require python-azure-cli-core.inc
require azure-cli-common.inc
