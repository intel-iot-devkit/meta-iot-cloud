inherit setuptools3
require python-azure-mgmt-datalake-store.inc
require azure-mgmt-datalake-common.inc
