inherit pypi setuptools
require python-azure-cli-role.inc