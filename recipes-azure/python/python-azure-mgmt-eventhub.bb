inherit setuptools
require python-azure-mgmt-eventhub.inc
require azure-mgmt-common.inc
