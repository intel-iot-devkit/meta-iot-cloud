inherit setuptools
require python-azure-mgmt-notificationhubs.inc
require azure-mgmt-common.inc
