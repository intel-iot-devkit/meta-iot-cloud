inherit setuptools3
require python-azure-mgmt-marketplaceordering.inc