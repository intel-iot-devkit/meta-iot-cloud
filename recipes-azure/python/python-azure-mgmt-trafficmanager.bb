inherit setuptools
require python-azure-mgmt-trafficmanager.inc
require azure-mgmt-common.inc
