inherit setuptools
require python-azure-mgmt-devtestlabs.inc
require python-azure-class.inc
