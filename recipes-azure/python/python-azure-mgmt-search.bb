inherit setuptools
require python-azure-mgmt-search.inc
require python-azure-class.inc
