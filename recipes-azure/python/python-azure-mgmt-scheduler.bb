inherit setuptools
require python-azure-mgmt-scheduler.inc
require azure-mgmt-common.inc
