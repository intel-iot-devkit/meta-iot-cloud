inherit setuptools3
require python-azure-cli-cdn.inc
require azure-cli-command-modules.inc
