inherit setuptools
require python-applicationinsights.inc
