inherit setuptools
require python-azure-mgmt-recoveryservices.inc
require azure-mgmt-common.inc
