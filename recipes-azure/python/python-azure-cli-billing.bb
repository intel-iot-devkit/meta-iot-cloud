inherit setuptools
require python-azure-cli-billing.inc
require azure-cli-command-modules.inc
