inherit setuptools
require python-azure-cli.inc
require azure-cli-common.inc
