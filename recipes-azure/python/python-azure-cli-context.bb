inherit setuptools
require python-azure-cli-context.inc
require python-azure-cli-common.inc
