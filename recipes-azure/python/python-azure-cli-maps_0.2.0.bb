inherit pypi setuptools
require python-azure-cli-maps.inc