inherit pypi setuptools
require python-azure-cli-dla.inc