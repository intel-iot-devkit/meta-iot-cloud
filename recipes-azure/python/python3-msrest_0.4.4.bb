inherit setuptools3
require python-msrest.inc
