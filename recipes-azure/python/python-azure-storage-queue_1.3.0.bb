inherit pypi setuptools
require python-azure-storage-queue.inc