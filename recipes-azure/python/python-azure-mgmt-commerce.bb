inherit setuptools
require python-azure-mgmt-commerce.inc
require azure-mgmt-common.inc
