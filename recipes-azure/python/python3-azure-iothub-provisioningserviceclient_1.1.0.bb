inherit setuptools3
require python-azure-iothub-provisioningserviceclient.inc
