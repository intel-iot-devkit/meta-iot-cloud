inherit setuptools3
require python-azure-mgmt-compute.inc
require azure-mgmt-common.inc
