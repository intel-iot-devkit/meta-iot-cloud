inherit setuptools
require python-azure-batch.inc
require python-azure-class.inc
