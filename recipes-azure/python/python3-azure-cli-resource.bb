inherit setuptools3
require python-azure-cli-resource.inc
require azure-cli-common.inc
