inherit setuptools
require python-azure-cli-devops.inc
require python-azure-cli-common.inc
