inherit setuptools
require python-azure-cli-feedback.inc
require python-azure-cli-common.inc
