inherit setuptools
require python-azure-mgmt-datalake-analytics.inc
require python-azure-class.inc
