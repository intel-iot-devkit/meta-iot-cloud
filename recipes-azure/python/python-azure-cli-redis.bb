inherit setuptools
require python-azure-cli-redis.inc
require azure-cli-command-modules.inc
