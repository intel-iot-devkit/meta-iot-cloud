inherit setuptools
require python-azure-cli-sql.inc
require python-azure-cli-common.inc
