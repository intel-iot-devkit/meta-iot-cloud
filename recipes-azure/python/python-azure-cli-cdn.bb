inherit setuptools
require python-azure-cli-cdn.inc
require azure-cli-common.inc
