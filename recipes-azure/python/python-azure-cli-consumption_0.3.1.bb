inherit pypi setuptools
require python-azure-cli-consumption.inc