inherit setuptools3
require python-azure-mgmt-containerinstance.inc
