inherit setuptools3
require python-azure-mgmt-devtestlabs.inc
require azure-mgmt-common.inc
