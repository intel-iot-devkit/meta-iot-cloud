inherit setuptools
require python-proto-google-cloud-logging-v2.inc
