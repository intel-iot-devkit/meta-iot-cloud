inherit setuptools3
require python-gapic-google-cloud-pubsub-v1.inc