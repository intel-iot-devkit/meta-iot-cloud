inherit setuptools
require python-google-cloud.inc
require python-google-cloud-common.inc
