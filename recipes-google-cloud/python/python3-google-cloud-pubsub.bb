inherit setuptools3

require python-google-cloud-pubsub.inc
require python3-google-cloud-common.inc
