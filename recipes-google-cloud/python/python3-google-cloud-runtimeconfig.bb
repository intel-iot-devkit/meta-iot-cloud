inherit setuptools3
require python-google-cloud-runtimeconfig.inc
require python3-google-cloud-common.inc
