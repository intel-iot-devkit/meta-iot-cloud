inherit setuptools
require python-google-cloud-pubsub.inc
require python-google-cloud-common.inc