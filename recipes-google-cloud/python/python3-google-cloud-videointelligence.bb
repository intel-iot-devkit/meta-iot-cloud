inherit setuptools3
require python-google-cloud-videointelligence.inc
require python3-google-cloud-common.inc
