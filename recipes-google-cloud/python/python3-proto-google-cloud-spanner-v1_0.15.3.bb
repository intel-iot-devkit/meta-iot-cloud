inherit setuptools3
require python-proto-google-cloud-spanner-v1.inc
