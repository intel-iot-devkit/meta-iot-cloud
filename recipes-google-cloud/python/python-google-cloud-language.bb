inherit setuptools
require python-google-cloud-language.inc
require python-google-cloud-common.inc
