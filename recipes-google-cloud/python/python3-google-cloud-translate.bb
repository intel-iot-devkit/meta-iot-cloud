inherit setuptools3
require python-google-cloud-translate.inc
require python3-google-cloud-common.inc
