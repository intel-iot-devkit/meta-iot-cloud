inherit setuptools
require python-google-cloud-videointelligence.inc
require python-google-cloud-common.inc
