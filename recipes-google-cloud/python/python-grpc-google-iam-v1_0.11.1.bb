inherit setuptools
require python-grpc-google-iam-v1.inc