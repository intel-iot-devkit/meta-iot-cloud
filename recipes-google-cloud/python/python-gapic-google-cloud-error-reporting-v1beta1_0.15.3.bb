inherit setuptools
require python-gapic-google-cloud-error-reporting-v1beta1.inc
