inherit setuptools
require python-google-auth-httplib2.inc