inherit setuptools
require python-google-cloud-dns.inc
require python-google-cloud-common.inc
