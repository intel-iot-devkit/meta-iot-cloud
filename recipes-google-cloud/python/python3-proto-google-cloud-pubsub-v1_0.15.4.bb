inherit setuptools3
require python-proto-google-cloud-pubsub-v1.inc