inherit setuptools
require python-gapic-google-cloud-pubsub-v1.inc