inherit setuptools3
require python-google-auth.inc
