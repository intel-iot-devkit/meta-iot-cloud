inherit setuptools
require python-proto-google-cloud-spanner-admin-instance-v1.inc
