inherit setuptools3
require python-grpc-google-cloud-logging-v2.inc