inherit setuptools
require python-gapic-google-cloud-speech-v1beta1.inc