inherit setuptools3
require python-google-auth-httplib2.inc