inherit setuptools
require python-google-cloud-bigtable.inc
require python-google-cloud-common.inc
