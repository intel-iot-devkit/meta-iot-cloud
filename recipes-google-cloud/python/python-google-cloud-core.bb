inherit setuptools
require python-google-cloud-core.inc
require python-google-cloud-common.inc
