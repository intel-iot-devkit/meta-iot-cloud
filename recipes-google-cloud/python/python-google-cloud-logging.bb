inherit setuptools
require python-google-cloud-logging.inc
require python-google-cloud-common.inc
