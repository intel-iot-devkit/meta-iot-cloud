inherit setuptools3
require python-google-api-core.inc
