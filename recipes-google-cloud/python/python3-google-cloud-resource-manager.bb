inherit setuptools3
require python-google-cloud-resource-manager.inc
require python3-google-cloud-common.inc
