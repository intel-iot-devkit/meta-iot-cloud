inherit setuptools
require python-proto-google-cloud-spanner-admin-database-v1.inc
