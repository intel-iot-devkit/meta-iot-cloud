inherit pypi setuptools
require python-googleapis-common-protos.inc
