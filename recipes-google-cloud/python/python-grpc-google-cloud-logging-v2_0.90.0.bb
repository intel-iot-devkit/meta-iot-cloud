inherit setuptools
require python-grpc-google-cloud-logging-v2.inc