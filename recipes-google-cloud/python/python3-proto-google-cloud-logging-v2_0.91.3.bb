inherit setuptools3
require python-proto-google-cloud-logging-v2.inc
