inherit setuptools
require python-google-cloud-runtimeconfig.inc
require python-google-cloud-common.inc
