inherit pypi setuptools
require python-google-cloud-storage.inc
