inherit setuptools3
require python-proto-google-cloud-error-reporting-v1beta1.inc
