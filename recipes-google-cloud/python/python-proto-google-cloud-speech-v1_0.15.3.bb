inherit setuptools
require python-proto-google-cloud-speech-v1.inc
