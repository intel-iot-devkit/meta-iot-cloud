inherit setuptools
require python-gapic-google-cloud-logging-v2.inc