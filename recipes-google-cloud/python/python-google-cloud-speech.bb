inherit setuptools
require python-google-cloud-speech.inc
require python-google-cloud-common.inc