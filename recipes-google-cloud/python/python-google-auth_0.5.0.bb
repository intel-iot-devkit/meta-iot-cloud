inherit setuptools
require python-google-auth.inc