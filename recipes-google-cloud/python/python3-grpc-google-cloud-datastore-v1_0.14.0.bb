inherit setuptools3
require python-grpc-google-cloud-datastore-v1.inc
