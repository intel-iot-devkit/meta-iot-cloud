inherit pypi setuptools3
require python-grpc-google-iam-v1.inc
