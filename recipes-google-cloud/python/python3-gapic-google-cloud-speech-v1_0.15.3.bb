inherit setuptools3
require python-gapic-google-cloud-speech-v1.inc
