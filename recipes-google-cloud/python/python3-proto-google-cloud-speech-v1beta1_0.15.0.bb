inherit setuptools3
require python-proto-google-cloud-speech-v1beta1.inc