inherit setuptools
require python-grpc-google-cloud-datastore-v1.inc
