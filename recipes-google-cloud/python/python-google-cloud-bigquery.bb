inherit setuptools
require python-google-cloud-bigquery.inc
require python-google-cloud-common.inc
