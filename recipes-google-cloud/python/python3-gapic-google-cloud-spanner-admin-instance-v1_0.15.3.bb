inherit setuptools3
require python-gapic-google-cloud-spanner-admin-instance-v1.inc
