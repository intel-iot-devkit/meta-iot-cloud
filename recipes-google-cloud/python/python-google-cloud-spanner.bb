inherit setuptools
require python-google-cloud-spanner.inc
require python-google-cloud-common.inc
