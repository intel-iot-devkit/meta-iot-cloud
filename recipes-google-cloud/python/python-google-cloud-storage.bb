inherit setuptools
require python-google-cloud-storage.inc
require python-google-cloud-common.inc