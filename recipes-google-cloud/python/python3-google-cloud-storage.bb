inherit setuptools3
require python-google-cloud-storage.inc
require python3-google-cloud-common.inc
