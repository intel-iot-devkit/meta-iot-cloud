inherit setuptools
require python-gapic-google-cloud-speech-v1.inc
