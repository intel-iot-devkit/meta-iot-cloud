inherit setuptools3
require python-google-cloud-error-reporting.inc
require python-google-cloud-common.inc