inherit setuptools
require python-google-cloud-resource-manager.inc
require python-google-cloud-common.inc