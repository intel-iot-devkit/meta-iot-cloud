inherit setuptools3
require python-google-cloud-storage.inc
