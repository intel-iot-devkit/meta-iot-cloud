inherit setuptools
require python-google-auth-oauthlib.inc
