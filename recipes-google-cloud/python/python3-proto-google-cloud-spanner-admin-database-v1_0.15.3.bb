inherit setuptools3
require python-proto-google-cloud-spanner-admin-database-v1.inc
