inherit setuptools3
require python-googleapis-common-protos.inc
