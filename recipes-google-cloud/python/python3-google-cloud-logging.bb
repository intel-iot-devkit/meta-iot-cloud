inherit setuptools3
require python-google-cloud-logging.inc
require python3-google-cloud-common.inc
