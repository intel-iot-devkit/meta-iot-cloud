inherit setuptools
require python-google-gax.inc