inherit setuptools3
require python-google-cloud-speech.inc
require python-google-cloud-common.inc