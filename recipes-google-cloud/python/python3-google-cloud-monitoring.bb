inherit setuptools3
require python-google-cloud-monitoring.inc
require python-google-cloud-common.inc
