inherit setuptools3
require python-google-cloud-spanner.inc
require python3-google-cloud-common.inc
