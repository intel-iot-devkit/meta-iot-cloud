inherit setuptools
require python-googleapis-common-protos.inc