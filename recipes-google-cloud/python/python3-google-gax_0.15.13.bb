inherit setuptools3
require python-google-gax.inc