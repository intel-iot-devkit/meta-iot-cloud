inherit setuptools3
require python-proto-google-cloud-spanner-admin-instance-v1.inc
