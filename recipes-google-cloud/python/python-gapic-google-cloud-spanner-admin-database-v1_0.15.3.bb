inherit setuptools
require python-gapic-google-cloud-spanner-admin-database-v1.inc
