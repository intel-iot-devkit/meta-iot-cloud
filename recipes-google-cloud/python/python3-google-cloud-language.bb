inherit setuptools3
require python-google-cloud-language.inc
require python-google-cloud-common.inc
