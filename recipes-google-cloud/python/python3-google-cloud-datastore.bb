inherit setuptools3
require python-google-cloud-datastore.inc
require python-google-cloud-common.inc