inherit setuptools
require python-google-resumable-media.inc
