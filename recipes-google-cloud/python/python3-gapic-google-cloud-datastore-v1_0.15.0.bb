inherit setuptools3
require python-gapic-google-cloud-datastore-v1.inc