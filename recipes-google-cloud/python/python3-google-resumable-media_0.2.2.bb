inherit setuptools3
require python-google-resumable-media.inc
