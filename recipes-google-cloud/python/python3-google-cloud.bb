inherit setuptools3
require python-google-cloud.inc
require python-google-cloud-common.inc
