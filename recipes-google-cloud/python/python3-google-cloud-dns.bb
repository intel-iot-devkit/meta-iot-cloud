inherit setuptools3
require python-google-cloud-dns.inc
require python-google-cloud-common.inc
