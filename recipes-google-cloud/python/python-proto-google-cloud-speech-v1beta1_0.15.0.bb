inherit setuptools
require python-proto-google-cloud-speech-v1beta1.inc