inherit setuptools3
require python-proto-google-cloud-datastore-v1.inc