inherit setuptools
require python-proto-google-cloud-pubsub-v1.inc