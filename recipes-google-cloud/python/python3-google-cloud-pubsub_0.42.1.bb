inherit pypi setuptools3
require python-google-cloud-pubsub.inc
