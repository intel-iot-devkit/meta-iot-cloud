inherit setuptools3
require python-google-cloud-happybase.inc
require python-google-cloud-common.inc
