inherit setuptools
require python-proto-google-cloud-datastore-v1.inc