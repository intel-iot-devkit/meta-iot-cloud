inherit setuptools
require python-gapic-google-cloud-spanner-v1.inc
