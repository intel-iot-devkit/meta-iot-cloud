inherit setuptools3
require python-google-cloud-vision.inc
require python-google-cloud-common.inc