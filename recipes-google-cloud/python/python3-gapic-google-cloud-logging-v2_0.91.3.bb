inherit setuptools3
require python-gapic-google-cloud-logging-v2.inc