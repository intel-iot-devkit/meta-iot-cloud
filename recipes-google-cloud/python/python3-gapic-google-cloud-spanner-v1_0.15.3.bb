inherit setuptools3
require python-gapic-google-cloud-spanner-v1.inc
