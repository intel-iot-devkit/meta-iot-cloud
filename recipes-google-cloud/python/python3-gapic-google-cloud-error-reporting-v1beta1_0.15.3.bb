inherit setuptools3
require python-gapic-google-cloud-error-reporting-v1beta1.inc
