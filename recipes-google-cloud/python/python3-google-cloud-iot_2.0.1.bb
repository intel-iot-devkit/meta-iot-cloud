inherit setuptools3
require python-google-cloud-iot.inc
