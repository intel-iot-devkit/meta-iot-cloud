inherit setuptools3
require python-google-cloud-bigtable.inc
require python-google-cloud-common.inc
