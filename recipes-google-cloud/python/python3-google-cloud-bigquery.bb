inherit setuptools3
require python-google-cloud-bigquery.inc
require python3-google-cloud-common.inc
