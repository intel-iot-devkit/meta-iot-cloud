inherit setuptools3
require python-google-cloud-core.inc
require python3-google-cloud-common.inc
