inherit setuptools
require python-gapic-google-cloud-datastore-v1.inc