inherit setuptools
require python-proto-google-cloud-spanner-v1.inc
