inherit native
require dotnet.inc
