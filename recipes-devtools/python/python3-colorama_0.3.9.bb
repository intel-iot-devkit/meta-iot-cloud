inherit pypi setuptools3
require python-colorama.inc
