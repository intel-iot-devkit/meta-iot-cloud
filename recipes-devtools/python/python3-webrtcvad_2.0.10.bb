inherit setuptools3
require python-webrtcvad.inc
