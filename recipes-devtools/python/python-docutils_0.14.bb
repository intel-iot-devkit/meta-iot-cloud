inherit setuptools
require python-docutils.inc
