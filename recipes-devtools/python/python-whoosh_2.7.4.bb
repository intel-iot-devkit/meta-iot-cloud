inherit setuptools
require python-whoosh.inc
