inherit setuptools
require python-paramiko.inc
