inherit setuptools3
require python-docutils.inc
