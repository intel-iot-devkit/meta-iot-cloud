inherit pypi setuptools
require python-setuptools-scm-git-archive.inc
