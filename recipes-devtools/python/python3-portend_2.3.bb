inherit pypi setuptools3
require python-portend.inc
