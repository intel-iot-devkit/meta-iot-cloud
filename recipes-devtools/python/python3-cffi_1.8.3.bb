inherit setuptools3
require python-cffi.inc
