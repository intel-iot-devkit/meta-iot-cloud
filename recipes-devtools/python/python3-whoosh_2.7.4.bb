inherit setuptools3
require python-whoosh.inc
