inherit setuptools3
require python-requests-toolbelt.inc
