inherit setuptools3
require python-pysocks.inc
