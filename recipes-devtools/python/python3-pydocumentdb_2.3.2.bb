inherit pypi setuptools3
require python-pydocumentdb.inc
