inherit setuptools3
require python-tenacity.inc
