inherit setuptools3
require python-memcached.inc
