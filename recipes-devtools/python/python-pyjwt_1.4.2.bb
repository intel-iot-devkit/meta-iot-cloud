inherit setuptools
require python-pyjwt.inc
