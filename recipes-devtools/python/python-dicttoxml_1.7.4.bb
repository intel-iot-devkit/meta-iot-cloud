inherit setuptools
require python-dicttoxml.inc
