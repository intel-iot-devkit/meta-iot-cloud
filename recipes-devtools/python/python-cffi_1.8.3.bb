inherit setuptools
require python-cffi.inc
