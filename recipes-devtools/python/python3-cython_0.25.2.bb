inherit setuptools3
require python-cython.inc
