inherit pypi setuptools3
require python-zc-lockfile.inc
