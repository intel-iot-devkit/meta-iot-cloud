inherit setuptools
require python-requests.inc
