inherit pypi setuptools
require python-requests-oauthlib.inc
