inherit pypi setuptools
require python-vsts-cd-manager.inc
