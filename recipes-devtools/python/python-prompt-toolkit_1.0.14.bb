inherit setuptools
require python-prompt-toolkit.inc
