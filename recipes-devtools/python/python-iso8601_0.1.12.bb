inherit setuptools
require python-iso8601.inc
