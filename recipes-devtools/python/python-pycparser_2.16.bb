inherit setuptools
require python-pycparser.inc
