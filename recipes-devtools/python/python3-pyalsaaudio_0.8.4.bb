inherit setuptools3
require python-pyalsaaudio.inc
