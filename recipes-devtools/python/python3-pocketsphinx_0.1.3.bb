inherit setuptools3
require python-pocketsphinx.inc
