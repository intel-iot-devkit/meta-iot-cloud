inherit setuptools3
require python-pydocumentdb.inc
