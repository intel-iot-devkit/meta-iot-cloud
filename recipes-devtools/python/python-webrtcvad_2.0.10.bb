inherit setuptools
require python-webrtcvad.inc
