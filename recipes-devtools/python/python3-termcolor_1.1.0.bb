inherit pypi setuptools3
require python-termcolor.inc
