inherit setuptools
require python-sounddevice.inc
