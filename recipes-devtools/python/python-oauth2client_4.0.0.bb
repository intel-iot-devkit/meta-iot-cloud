inherit setuptools
require python-oauth2client.inc
