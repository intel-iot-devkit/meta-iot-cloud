inherit setuptools3
require python-vlc.inc
