inherit setuptools3
require python-scp.inc
