inherit setuptools3
require python-certifi.inc
