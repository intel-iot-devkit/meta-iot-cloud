inherit setuptools
require python-pathlib2.inc
