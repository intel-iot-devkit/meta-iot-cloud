inherit setuptools
require python-wcwidth.inc
