inherit setuptools3
require python-repoze-lru.inc
