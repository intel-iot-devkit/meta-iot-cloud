inherit setuptools3
require python-fire.inc
