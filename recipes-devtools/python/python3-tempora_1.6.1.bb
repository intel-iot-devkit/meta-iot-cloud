inherit setuptools3
require python-tempora.inc
