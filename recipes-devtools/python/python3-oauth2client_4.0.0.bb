inherit setuptools3
require python-oauth2client.inc
