inherit pypi setuptools3
require python-knack.inc
