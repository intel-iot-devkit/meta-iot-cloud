inherit setuptools3
require python-cheroot.inc
