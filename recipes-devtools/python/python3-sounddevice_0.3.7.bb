inherit setuptools3
require python-sounddevice.inc
