inherit setuptools3
require python-jmespath.inc
