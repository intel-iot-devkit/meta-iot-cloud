inherit setuptools3
require python-pyopenssl.inc
