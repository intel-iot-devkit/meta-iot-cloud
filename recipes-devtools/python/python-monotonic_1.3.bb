inherit setuptools
require python-monotonic.inc
