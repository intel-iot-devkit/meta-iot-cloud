inherit setuptools
require python-cheroot.inc
