inherit pypi setuptools3
require python-jeepney.inc