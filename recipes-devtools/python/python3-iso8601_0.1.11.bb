inherit setuptools3
require python-iso8601.inc
