inherit setuptools
require python-memcached.inc
