inherit setuptools3
require python-routes.inc
