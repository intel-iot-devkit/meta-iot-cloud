SUMMARY = "Cross-platform colored terminal text."
AUTHOR = "Arnon Yaari"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=14d0b64047ed8f510b51ce0495995358"

SRC_URI[md5sum] = "88dc534278e3e3a7b7988cb3fae76c4a"
SRC_URI[sha256sum] = "ec9efcccb086a1d727876384f94ee6358d2f3f096688c1ba18b0f318f2b453b5"

inherit pypi
