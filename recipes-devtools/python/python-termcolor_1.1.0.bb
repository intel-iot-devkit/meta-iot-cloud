inherit pypi setuptools
require python-termcolor.inc
