inherit setuptools
require python-tempora.inc
