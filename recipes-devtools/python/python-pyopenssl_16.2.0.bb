inherit setuptools
require python-pyopenssl.inc
