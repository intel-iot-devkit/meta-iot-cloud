inherit setuptools
require python-repoze-lru.inc
