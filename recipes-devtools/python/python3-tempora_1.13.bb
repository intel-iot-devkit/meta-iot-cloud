inherit pypi setuptools3
require python-tempora.inc
