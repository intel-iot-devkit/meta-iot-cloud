inherit setuptools
require python-dill.inc
