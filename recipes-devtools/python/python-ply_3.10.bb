inherit setuptools
require python-ply.inc
