inherit pypi setuptools
require python-isodate.inc
