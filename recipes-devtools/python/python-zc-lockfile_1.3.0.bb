inherit pypi setuptools
require python-zc-lockfile.inc
