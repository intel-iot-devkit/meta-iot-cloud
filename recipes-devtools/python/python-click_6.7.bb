inherit setuptools
require python-click.inc
