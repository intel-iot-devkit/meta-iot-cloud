inherit setuptools
require python-requests-oauthlib.inc
