inherit setuptools3
require python-requests-oauthlib.inc
