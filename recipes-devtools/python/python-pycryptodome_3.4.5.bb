inherit setuptools
require python-pycryptodome.inc
