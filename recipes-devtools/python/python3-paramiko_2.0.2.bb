inherit setuptools3
require python-paramiko.inc
