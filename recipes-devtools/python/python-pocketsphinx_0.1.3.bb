inherit setuptools
require python-pocketsphinx.inc
