inherit setuptools
require python-pyasn1.inc
