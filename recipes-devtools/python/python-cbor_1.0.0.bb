inherit pypi setuptools
require python-cbor.inc
