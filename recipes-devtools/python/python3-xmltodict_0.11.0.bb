inherit pypi setuptools3
require python-xmltodict.inc
