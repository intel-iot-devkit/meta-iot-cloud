inherit setuptools
require python-idna.inc
