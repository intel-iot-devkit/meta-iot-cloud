inherit setuptools
require python-scandir.inc
