inherit setuptools
require python-fire.inc
