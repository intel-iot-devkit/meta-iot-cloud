inherit setuptools
require python-vlc.inc
