inherit setuptools
require python-certifi.inc
