inherit setuptools
require python-cython.inc
