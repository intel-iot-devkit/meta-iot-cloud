inherit setuptools
require python-tabulate.inc
