inherit setuptools3
require python-idna.inc
