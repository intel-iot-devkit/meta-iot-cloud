inherit setuptools3
require python-click.inc
