inherit setuptools
require python-pydocumentdb.inc
