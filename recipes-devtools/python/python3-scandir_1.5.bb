inherit setuptools3
require python-scandir.inc
