inherit setuptools3
require python-portend.inc
