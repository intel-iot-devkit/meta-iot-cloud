inherit setuptools
require python-pyasn1-modules.inc