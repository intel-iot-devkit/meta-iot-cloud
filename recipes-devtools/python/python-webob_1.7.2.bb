inherit setuptools
require python-webob.inc
