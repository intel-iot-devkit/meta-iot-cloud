inherit setuptools3
require python-xmltodict.inc
