inherit setuptools3
require python-dill.inc
