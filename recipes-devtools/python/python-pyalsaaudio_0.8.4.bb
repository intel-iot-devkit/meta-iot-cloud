inherit setuptools
require python-pyalsaaudio.inc
