inherit setuptools
require python-routes.inc
