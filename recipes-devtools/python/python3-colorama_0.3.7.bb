inherit setuptools3
require python-colorama.inc
