inherit pypi setuptools3
require python-cherrypy.inc
