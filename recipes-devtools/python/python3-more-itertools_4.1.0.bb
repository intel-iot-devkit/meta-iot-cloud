inherit setuptools3
require python-more-itertools.inc
