inherit setuptools3
require python-pygments.inc
