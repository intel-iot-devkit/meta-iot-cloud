inherit setuptools3
require python-monotonic.inc
