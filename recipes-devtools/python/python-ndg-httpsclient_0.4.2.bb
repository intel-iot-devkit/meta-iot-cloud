inherit setuptools
require python-ndg-httpsclient.inc
