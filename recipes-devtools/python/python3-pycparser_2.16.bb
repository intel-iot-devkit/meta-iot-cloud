inherit setuptools3
require python-pycparser.inc
