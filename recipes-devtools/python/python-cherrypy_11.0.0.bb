inherit setuptools
require python-cherrypy.inc
