inherit setuptools
require python-oauthlib.inc
