inherit setuptools3
require python-argcomplete.inc
