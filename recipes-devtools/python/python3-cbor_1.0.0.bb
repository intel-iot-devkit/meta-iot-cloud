inherit pypi setuptools3
require python-cbor.inc
