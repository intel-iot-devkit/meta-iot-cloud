inherit pypi setuptools3
require python-cheroot.inc
