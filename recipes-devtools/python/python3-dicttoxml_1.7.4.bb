inherit setuptools3
require python-dicttoxml.inc
