inherit pypi setuptools3
require python-scp.inc
