inherit pypi setuptools3
require python-entrypoints.inc
