inherit pypi setuptools3
require python-tabulate.inc
