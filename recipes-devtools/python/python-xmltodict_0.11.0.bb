inherit setuptools
require python-xmltodict.inc
