inherit setuptools
require python-scp.inc
