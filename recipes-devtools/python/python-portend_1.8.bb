inherit setuptools
require python-portend.inc
