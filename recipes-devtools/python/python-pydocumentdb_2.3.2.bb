inherit pypi setuptools
require python-pydocumentdb.inc

RDEPENDS_${PN} += "\
	${PYTHON_PN}-lang \
"