inherit setuptools3
require python-wcwidth.inc
