inherit setuptools
require python-httplib2.inc