inherit pypi setuptools3
require python-sshtunnel.inc
