inherit pypi setuptools
require python-tempora.inc

RDEPENDS_${PN} += "\
	${PYTHON_PN}-lang \
"
