inherit setuptools
require python-more-itertools.inc
