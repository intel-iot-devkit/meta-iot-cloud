inherit pypi setuptools3
require python-httplib2.inc