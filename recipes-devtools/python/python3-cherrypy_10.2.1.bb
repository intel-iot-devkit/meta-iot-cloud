inherit setuptools3
require python-cherrypy.inc
