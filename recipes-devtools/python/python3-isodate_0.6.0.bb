inherit pypi setuptools3
require python-isodate.inc
