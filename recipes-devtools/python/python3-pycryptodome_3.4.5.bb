inherit setuptools3
require python-pycryptodome.inc
