inherit pypi setuptools3
require python-msrest.inc
