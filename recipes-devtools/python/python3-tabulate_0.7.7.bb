inherit setuptools3
require python-tabulate.inc
