inherit pypi setuptools3
require python-setuptools-scm-git-archive.inc
