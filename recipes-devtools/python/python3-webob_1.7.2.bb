inherit setuptools3
require python-webob.inc
