inherit setuptools
require python-pysocks.inc
