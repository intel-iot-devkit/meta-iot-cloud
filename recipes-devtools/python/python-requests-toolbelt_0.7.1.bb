inherit setuptools
require python-requests-toolbelt.inc
