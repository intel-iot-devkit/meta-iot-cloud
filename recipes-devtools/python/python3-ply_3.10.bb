inherit setuptools3
require python-ply.inc
