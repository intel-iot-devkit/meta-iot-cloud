inherit setuptools3
require python-pubnub.inc
