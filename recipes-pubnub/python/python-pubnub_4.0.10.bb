inherit setuptools
require python-pubnub.inc
