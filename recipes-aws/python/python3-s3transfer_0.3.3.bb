inherit setuptools3
require python-s3transfer.inc
