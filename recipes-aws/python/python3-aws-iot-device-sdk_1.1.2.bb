inherit setuptools3
require python-aws-iot-device-sdk.inc
