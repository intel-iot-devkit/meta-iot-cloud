inherit setuptools
require python-awscli.inc
