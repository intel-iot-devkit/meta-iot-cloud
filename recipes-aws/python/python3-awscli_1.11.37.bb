inherit setuptools3
require python-awscli.inc
