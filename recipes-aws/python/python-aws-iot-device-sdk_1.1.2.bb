inherit setuptools
require python-aws-iot-device-sdk.inc
