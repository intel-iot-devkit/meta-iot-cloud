inherit setuptools
require python-gg-group-setup.inc
