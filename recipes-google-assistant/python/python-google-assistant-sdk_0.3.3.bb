inherit setuptools
require python-google-assistant-sdk.inc
