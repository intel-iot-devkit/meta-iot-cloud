inherit setuptools
require python-google-assistant-grpc.inc
