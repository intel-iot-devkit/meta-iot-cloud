inherit setuptools3
require python-google-assistant-grpc.inc
