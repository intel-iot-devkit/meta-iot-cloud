inherit setuptools3
require python-google-assistant-sdk.inc
