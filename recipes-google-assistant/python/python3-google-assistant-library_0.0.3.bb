inherit python-dir
require python-google-assistant-library.inc
